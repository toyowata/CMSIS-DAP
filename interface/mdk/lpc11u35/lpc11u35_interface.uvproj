# Keil uVision project lpc11u35_interface.uvproj, settings and files
target lpc11u35_lpc812_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lpc11u35_lpc812_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC812, BOARD_LPC812_MAX
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC812;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos;..\..\..\shared\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: ..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX\TOOLCHAIN_ARM_STD\LPC11U35.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/: system_LPC11Uxx.c
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/TOOLCHAIN_ARM_STD/: startup_LPC11Uxx.s
  group Common
    ../../Common/src/: DAP.c dap_vendor_command.c main.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c board.c serial.c virtual_fs.c
    ../../interface/hal/TARGET_NXP/TARGET_LPC11U35/: usb_config.c
    ../../Common/inc/: mbed_htm.h
  group HAL-Interface
    ../../interface/hal/TARGET_NXP/TARGET_LPC11U35/: DAP_config.h gpio.c read_uid.c uart.c usbd_LPC11Uxx.c usb_buf.h
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM1.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group HAL-Target-LPC1114
    ../../target/hal/DBG_NXP/DBG_LPC1114/: target_reset.c lpc1114_app_config.c
    ../../target/hal/DBG_NXP/: target_flash.c
  group HAL-Target-LPC1768
    ../../target/hal/DBG_NXP/DBG_LPC1768/: target_reset.c
    ../../target/hal/DBG_NXP/: target_flash.c
  group HAL-Target-LPC812
    ../../target/hal/DBG_NXP/DBG_LPC812/: target_reset.c
    ../../target/hal/DBG_NXP/: target_flash.c
  group HAL-Target-LPC824
    ../../target/hal/DBG_NXP/DBG_LPC824/: lpc824_app_config.c target_reset.c
    ../../target/hal/DBG_NXP/: target_flash.c
  group HAL-Target-RZA1H
    ../../target/hal/DBG_Renesas/: swd_host_ca.c target_flash.c
    ../../target/hal/DBG_Renesas/DBG_RZA1H/: rza1h_app_config.c target_reset.c
target lpc11u35_lpc812_mbed_bootloader (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc812_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3
  c define: TARGET_LPC11U35, __RTX, DBG_LPC812, BOARD_LPC812_MAX
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\interface\cmsis;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\target\hal\DBG_NXP\DBG_LPC812;..\..\..\shared\rtos;..\..\..\shared\cmsis
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x5000 size 0xb000
  memory RVCT9: RAM 0x100000c0 size 0x1f40
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: ..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX\TOOLCHAIN_ARM_STD\LPC11U35_mbed_bootloader.sct
target lpc11u35_lpc1114_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc1114_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1114, BOARD_LPC1114,OS_STKCHECK=0
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC1114;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos;..\..\..\shared\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_lpc1114_mbed_bootloader (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc1114_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1114, BOARD_LPC1114
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_lpc1768_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc1768_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1768, BOARD_SEEED_ARCH_PRO
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC1768;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos;..\..\..\shared\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_lpc1768_mbed_bootloader (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc1768_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1768, BOARD_SEEED_ARCH_PRO
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_ublox_lpc1768_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_ublox_lpc1768_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1768, BOARD_UBLOX_C027
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_lpc824_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc824_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC824, BOARD_LPC824,OS_STKCHECK=0
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC824;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos;..\..\..\shared\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11U35_rza1h_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_rza1h_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_RZA1H, BOARD_RZA1H,OS_STKCHECK=0
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_Renesas\DBG_RZA1H;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos;..\..\..\shared\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
