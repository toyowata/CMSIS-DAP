# Keil uVision project lpc4322_interface.uvproj, settings and files
target lpc4322_lpc1549_if (ARM-ADS)
  device: LPC4322 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20003FFF) IROM(0x1A000000-0x1A07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: lpc4322_lpc1549_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1a000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 oTime=1
  c define: CORE_M4,TARGET_LPC4322, __RTX, DBG_LPC1549, BOARD_LPC1549,USE_FPU,INTERNAL_FLASH
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC1549;..\..\interface\hal\TARGET_NXP\TARGET_LPC4322;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC4322;..\..\..\shared\rtos
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT8: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC4322/: system_LPC43xx.c fpu_enable.c
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC4322/TOOLCHAIN_ARM_STD/: startup_LPC43xx.s
  group Common
    ../../Common/src/: DAP.c dap_vendor_command.c main.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c board.c serial.c virtual_fs.c
    ../../interface/hal/TARGET_NXP/TARGET_LPC4322/: usb_config.c
    ../../Common/inc/: mbed_htm.h
  group HAL-Interface
    ../../interface/hal/TARGET_NXP/TARGET_LPC4322/: DAP_config.h gpio.c read_uid.c uart.c usb_buf.h usbd_LPC43xx_USB0.c board_LPC43xx.c lpc43xx_cgu.c lpc43xx_scu.c
  group HAL-Target
    ../../target/hal/DBG_NXP/DBG_LPC11U68/: target_reset_LPC11U68.c lpc11u68_app_config.c
    ../../target/hal/DBG_NXP/DBG_LPC1549/: target_reset_LPC1549.c lpc1549_app_config.c
    ../../target/hal/DBG_NXP/DBG_LPC4337/: target_reset_LPC4337.c lpc4337_app_config.c
    ../../target/hal/DBG_NXP/: target_flash.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM4.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
target lpc4322_lpc1549_dbg_sram (ARM-ADS)
  device: LPC4320 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: lpc4322_lpc1549_if_mbed_debug_only
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=1
  c define: CORE_M4,TARGET_LPC4322, __RTX, DBG_LPC1549, BOARD_LPC1549,USE_FPU
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x11000
  memory RVCT8: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10011000 size 0x7000
  memory RVCT10: RAM 0x20000000 size 0x10000
target lpc4322_lpc11U68_if (ARM-ADS)
  device: LPC4322 NXP (founded by Philips)
  cpu: as above
  output: lpc4322_lpc11U68_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1a000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 oTime=1
  c define: CORE_M4,TARGET_LPC4322, __RTX, DBG_LPC11U68, BOARD_LPC11U68,USE_FPU,INTERNAL_FLASH
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC11U68;..\..\interface\hal\TARGET_NXP\TARGET_LPC4322;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC4322;..\..\..\shared\rtos
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT8: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x4000
target lpc4322_lpc11U68_dbg_sram (ARM-ADS)
  device: LPC4320 NXP (founded by Philips)
  cpu: as above
  output: lpc4322_lpc11U68_if_mbed_debug_only
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=1
  c define: CORE_M4,TARGET_LPC4322, __RTX, DBG_LPC11U68, BOARD_LPC11U68,USE_FPU
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x11000
  memory RVCT8: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10011000 size 0x7000
  memory RVCT10: RAM 0x20000000 size 0x10000
target lpc4322_lpc4337_if (ARM-ADS)
  device: LPC4322 NXP (founded by Philips)
  cpu: as above
  output: lpc4322_lpc4337_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1a000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 oTime=1
  c define: CORE_M4,TARGET_LPC4322, __RTX, DBG_LPC4337, BOARD_LPC4337,USE_FPU,INTERNAL_FLASH
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC4337;..\..\interface\hal\TARGET_NXP\TARGET_LPC4322;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC4322;..\..\..\shared\rtos
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT8: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x4000
